# Keil uVision project RTOS-Rookie.uvproj, settings and files
target RTOS-Rookie (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: RTOS-Rookie +hex
  AfterMake: "F:\Code Library\GPU\Microsoft Visual Studio\Compile Counter\Compile_Controller\Debug\Compile_Controller.exe"
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM3210B_EVAL
  c include: ..\RTOS-Rookie(CM3);..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Utilities\STM32_EVAL\Common;..\..\Utilities\STM32_EVAL\STM3210B_EVAL;..\..\Utilities\STM32_EVAL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: kernel.c memory.c applications.c miscellaneous.c resource.c signal.c filesystem.c error.c GUI.c GUI_arch.c shell.c shell_arch.c
    ./Filesystems/NOFS/: NOFS.c NOFS_arch.c
  group Std_Periph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval.c
  group RVMDK
    ./: Arch.s startup_stm32f10x_md.s
